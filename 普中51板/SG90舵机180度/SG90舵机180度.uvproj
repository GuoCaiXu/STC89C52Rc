# Keil uVision project SG90舵机180度.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SG90舵机180度 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\key;.\App\sg90;.\Public
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group App
    ./App/key/: key.c
    ./App/sg90/: sg90.c
  group Public
    ./Public/: public.c
