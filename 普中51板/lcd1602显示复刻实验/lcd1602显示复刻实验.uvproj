# Keil uVision project lcd1602显示复刻实验.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lcd1602显示复刻实验 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\lcd1602
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group App
    ./App/lcd1602/: lcd1602.c
  group Public
    ./Public/: public.c
