# Keil uVision project DS18B20.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\smg;.\Public;.\App\DS10B20
  group User
    ./User/: main.c
  group App
    ./App/smg/: smg.c
    ./App/DS10B20/: ds18b20.c
  group Public
    ./Public/: public.c
