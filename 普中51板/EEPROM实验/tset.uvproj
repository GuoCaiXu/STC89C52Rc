# Keil uVision project tset.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: tset +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\key;.\App\smg;.\App\iic
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group App
    ./App/key/: key.c
    ./App/smg/: smg.c
    ./App/iic/: iic.c
  group Public
    ./Public/: public.c
