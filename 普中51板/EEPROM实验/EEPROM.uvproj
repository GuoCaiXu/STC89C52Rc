# Keil uVision project EEPROM.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: EEPROM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\iic;.\App\key;.\App\smg;.\App\at24c02
  asm include: .\Public;.\App\iic;.\App\key;.\App\smg
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group App
    ./App/iic/: iic.c
    ./App/key/: key.c
    ./App/smg/: smg.c
    ./App/at24c02/: at24c02.c
  group Public
    ./Public/: public.c
