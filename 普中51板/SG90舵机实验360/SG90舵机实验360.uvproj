# Keil uVision project SG90舵机实验360.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SG90舵机实验 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\sg90;.\App\key;.\Public
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group App
    ./App/sg90/: sg90.c
    ./App/key/: key.c
  group Public
    ./Public/: public.c
