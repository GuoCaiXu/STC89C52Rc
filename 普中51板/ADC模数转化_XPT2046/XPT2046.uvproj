# Keil uVision project XPT2046.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: XPT2046 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\smg;.\App\xpt2046
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group App
    ./App/smg/: smg.c
    ./App/xpt2046/: xpt2046.c
  group Public
    ./Public/: public.c
