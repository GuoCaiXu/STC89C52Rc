# Keil uVision project 红外遥控实验.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 红外遥控实验 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\hs0038;.\App\smg
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group App
    ./App/hs0038/: hs0038.c
    ./App/smg/: smg.c
  group Public
    ./Public/: public.c
