# Keil uVision project ssd1306_iic显示.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ssd1306_iic显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App
  group App
    ./: STARTUP.A51
    ./App/: OLED12864.c
