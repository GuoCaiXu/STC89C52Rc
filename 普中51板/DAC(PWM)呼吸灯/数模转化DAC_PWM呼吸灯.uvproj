# Keil uVision project 数模转化DAC_PWM呼吸灯.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 数模转化DAC_PWM呼吸灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\pwm;.\Public
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group App
    ./App/pwm/: pwm.c
  group Public
    ./Public/: public.c
